# Keil uVision project ParkingAssist.uvprojx, settings and files
target ParkingAssist (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: parking_assist +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\app\inc;..\middleware\inc;..\drivers\inc;..\middleware\FreeRTOS\include;..\middleware\FreeRTOS\portable\GCC\ARM_CM3;..\platform\cmsis\core;..\platform\cmsis\device;..\platform\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../platform/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../platform/cmsis/device/: system_stm32f10x.c
  group StdPeriph_Driver
    ../platform/StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_i2c.c
  group FreeRTOS
    ../middleware/FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c
    ../middleware/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../middleware/FreeRTOS/portable/MemMang/: heap_4.c
  group Drivers
    ../drivers/src/: clock.c nvic.c gpio.c exti.c spi.c uart.c timer.c pwm.c i2c.c capture.c delay.c
  group Middleware
    ../middleware/src/: board.c hcsr04.c ir_sensor.c light_sensor.c max7219.c buzzer.c ssd1306.c font3x5.c font5x7.c console.c cpu_monitor.c xprintf.c
  group App
    ../app/src/: main.c app_interface.c sonar_task.c sensor_task.c dist_filter.c control_task.c parking_fsm.c console_task.c display_task.c parking_view.c cpu_view.c oled_task.c log_task.c hooks.c
    ../app/inc/: FreeRTOSConfig.h app_interface.h app_config.h parking_types.h
